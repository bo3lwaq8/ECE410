* 4x4 Resistive Crossbar for Matrix-Vector Multiplication
*
* This circuit demonstrates how a crossbar array performs the operation:
* I_out = G * V_in
* where G is the conductance matrix (1/R) and V_in is the input voltage vector.

* --- 1. Input Voltage Sources (Input Vector V) ---
* These sources represent the 4x1 input vector.
* V = [1V, 2V, 0V, 1V]
Vin1 in1 0 DC 1V
Vin2 in2 0 DC 2V
Vin3 in3 0 DC 0V
Vin4 in4 0 DC 1V

* --- 2. Resistive Crossbar Array (Weight Matrix W, or Conductance Matrix G) ---
* The resistors represent the synaptic weights. Their conductance G = 1/R forms the matrix.
* G = [[1, 0, 1, 0],
* [0, 1, 0, 1],
* [1, 1, 0, 0],
* [0, 0, 1, 1]]
*
* We use a very high resistance (1G Ohm) for a conductance of ~0 (OFF state)
* and 1 Ohm for a conductance of 1 (ON state).

* Row 1 connections
R11 in1 out1 1
R12 in1 out2 1G
R13 in1 out3 1
R14 in1 out4 1G

* Row 2 connections
R21 in2 out1 1G
R22 in2 out2 1
R23 in2 out3 1G
R24 in2 out4 1

* Row 3 connections
R31 in3 out1 1
R32 in3 out2 1
R33 in3 out3 1G
R34 in3 out4 1G

* Row 4 connections
R41 in4 out1 1G
R42 in4 out2 1G
R43 in4 out3 1
R44 in4 out4 1

* --- 3. Output Lines (Output Current Vector I) ---
* The output currents are measured along the vertical "bitlines".
* We use 0V sources as ammeters to measure the current flowing into each output line.
* The output nodes are held at a virtual ground (0V).
Vout1 out1 0 DC 0V
Vout2 out2 0 DC 0V
Vout3 out3 0 DC 0V
Vout4 out4 0 DC 0V

* --- 4. Simulation Control ---
* Use an Operating Point (.op) analysis to find the DC solution.
.op
.end
